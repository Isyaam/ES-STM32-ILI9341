# Keil uVision project STM32F429_DISCO_Start.uvprojx, settings and files
target Debug_V5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429_DISCO_Start_Debug_V5
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORTEX_M=4 DEBUG
  c misc: --no_rtti --exceptions --no_unaligned_access --cpp11 --debug  --protect_stack
  c include: .\Inc;.\Inc\Debug;.\Inc\Cortex;.\Inc\Drivers;.\Inc\Utilities
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429_DISCO_Start.sct
  group Sources
    ./: STM32F429_DISCO_Start.cpp InitSDRAM.cpp
    ./Src/: DrvSpi.cpp ILI9341.cpp DrvLtdc.cpp Dma2d.cpp
  group Utilities
    ./Src/Utilities/: Formatter.cpp
  group Startup
    ./: STM32F429_startup.s STM32F429_init.cpp
  group STM32F-Periphery
    ./Src/Drivers/: RB.cpp DrvDio.cpp DrvDioG.cpp
  group Cortex
    ./Src/Cortex/: Faults.cpp Cortex.cpp ArmExclusive.s PSV.cpp STK.cpp SVC.cpp
  group Debug
    ./Src/Debug/: Debug.cpp
  group Target
    ./Src/Target/: Retarget.cpp PreMain.cpp MyStuff.cpp Initialize.cpp
target Debug_V6 (6120000::V6.12::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: STM32F429_DISCO_Start_Debug_V6
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: CORTEX_M=4 DEBUG
  c misc: -fstack-protector-strong -pedantic-errors -pedantic -mno-unaligned-access -mfpu=none -mfloat-abi=hard
  c include: .\Inc;.\Inc\Debug;.\Inc\Cortex;.\Inc\Drivers;.\Inc\Utilities
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429_DISCO_Start.sct
